# Keil uVision project DATA STORAGE CENTRE.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: DATA STORAGE CENTRE
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s can_driver.c delay.c EEPROM.c header.h i2c_driver.c main_rx.c uart_driver.c
